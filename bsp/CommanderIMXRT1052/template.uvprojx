# Keil uVision project template.uvprojx, settings and files
target IMXRT1052_ram_debug (ARM-ADS)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.2
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  scatter file: .\Script\rt1052_ram_scf.scf

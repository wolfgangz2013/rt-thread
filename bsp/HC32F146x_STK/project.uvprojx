# Keil uVision project project.uvprojx, settings and files
target rtthread-hc32 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F146KA HDSC
  pack: HDSC.HC32F_M14.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F146KX
  c misc: --diag_suppress=186
  c include: applications;.;drivers;Libraries\CMSIS\HC32FM14\Include;Libraries\HC32F146x_Driver\Inc;..\..\include;..\..\libcpu\arm\cortex-m0plus;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*.o(*_IrqHandler)   --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)  --keep *.o(VSymTab)
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_lcd.c drv_usart.c
  group Libraries
    Libraries/CMSIS/HC32FM14/Source/: system_hc32f_m14x.c startup_hc32f_m14x.s
    Libraries/HC32F146x_Driver/src/: clk.c ddl.c gpio.c interrupts_hc32f_m14x.c lcd.c uart.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M0PLUS
    ../../libcpu/arm/cortex-m0plus/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c

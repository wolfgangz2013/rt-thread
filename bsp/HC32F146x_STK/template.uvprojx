# Keil uVision project template.uvprojx, settings and files
target rtthread-hc32 (ARM-ADS)
  device: HC32F146KA HDSC
  pack: HDSC.HC32F_M14.1.0.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --diag_suppress=186
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
